v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {CNR_GR02_SKY130NM/CNR_GR02.sym} 200 80 0 0 {name=x1}
